# Keil uVision project BH-F103.uvprojx, settings and files
target LDC (6240000::V6.24::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER, FNN_MODEL_FROM_SD, SD_BATCH_TEST_LCD
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_sdio.c
  group USER
    ../../User/: main.c stm32f10x_it.c digit_app.c wifi_report.c fnn.c FNN_Data.c fnn_model.c emnist_cnn.c emnist_cnn_data.c sd_batch_test.c font_stubs.c
    ../../User/usart/: bsp_usart.c
    ../../User/led/: bsp_led.c
    ../../User/Lcd/: bsp_ili9341_lcd.c
    ../../User/lcd/: bsp_xpt2046_lcd.c
    ../../User/sdio/: bsp_sdio_sdcard.c
    ../../User/FATFS/: ff.c diskio_sdtest.c
    ../../User/key/: bsp_key.c
  group DOC
    ../../Doc/: readme.txt
